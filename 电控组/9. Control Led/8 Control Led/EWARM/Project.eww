<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\8 Control Led.ewp</path>
  </project>
  <batchBuild />
</workspace>
